# IAR project L2CAP_client.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; USER_BUTTON=BSP_PUSH1; BLE_STACK_FULL_CONF; CONFIG_DEVICE_BLUENRG_355; PRINT_DEBUG_INFO
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: CMSIS\Include; CMSIS\Device\ST\BlueNRG_LP\Include; Drivers\Peripherals_Drivers\Inc; Drivers\BSP\Inc; Drivers\BSP\Components\lps22hh_STdC\driver; Drivers\BSP\Components\lsm6dsox_STdC\driver; Middlewares\Hal\Inc; Middlewares\AESMGR\Inc; Middlewares\BLE_Application\OTA\inc; Middlewares\BLE_Application\Profile_Central\Inc; Middlewares\BLE_Application\Profiles\Inc; Middlewares\BLE_Application\Queued_Write\Inc; Middlewares\BLE_Application\layers_inc; Middlewares\Bluetooth_LE\inc; Middlewares\NVMDB\Inc; Middlewares\BLECNTR\Inc; Middlewares\PKA\Inc; Middlewares\RNG\Inc; Middlewares\cryptolib\inc\AES\Common; Middlewares\cryptolib\inc\AES\CMAC; Middlewares\cryptolib\inc\AES; Middlewares\cryptolib\inc\Common; Middlewares\cryptolib\inc; Inc\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestIOMapper_proj.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\TestIOMapper_proj.bin"
  ILINK.IlinkOutputFile: TestIOMapper_proj.out
  ILINK.IlinkConfigDefines: CONFIG_DEVICE_BLUENRG_355=1
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    Drivers/BSP/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_mic.c bluenrg_lp_evb_spi.c
    Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    CMSIS/Device/ST/BlueNRG_LP/Source/: startup_BlueNRG_LP.c system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    Drivers/Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pka_v7b.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c
  group Middlewares/AESMGR
    Middlewares/AESMGR/Src/: aes_manager.c aes_manager_bluenrg_lp.c
  group Middlewares/BLE_Application
    Middlewares/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/BLE_Stack
    Middlewares/BLE_Stack/: libbluenrg_lp_stack.a
  group Middlewares/BLECNTR
    Middlewares/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/Bluetooth_LE
    Middlewares/Bluetooth_LE/src/: stack_user_cfg.c
  group Middlewares/cryptolib
    Middlewares/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/Hal
    Middlewares/Hal/Src/: blue_unit_conversion.s clock.c context_switch.s fifo.c gp_timer.c hal_miscutil.c miscutil.c osal.c osal_memcpy.s radio_ota.c
  group Middlewares/NVMDB
    Middlewares/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/PKA
    Middlewares/PKA/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/RNG
    Middlewares/RNG/Src/: rng_manager.c rng_manager_bluenrg_lp.c
  group User
    Src/: bluenrg_lp_hw_config.c bluenrg_lp_it.c events.c project_main.c User.c
